# IAR project Project.ewp, settings and files
configuration Blue_Tile (ARM)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; no_ENABLE_USART; BLUENRG2_DEVICE; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DISABLE_TRACES; LPS22HH_ENABLED; LSM6DSO_ENABLED; HTS221_ENABLED; BLUETILE_SMART_SENSOR; BLUENRG_TILE; SERVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Drivers\BSP\Components\VL53L1X_UltraLite\inc; ..\..\..\..\..\..\Drivers\BSP\PWM\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\OTA\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\Utils\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc; ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc; ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc; ..\..\..\..\..\..\Projects\BlueNRG-2\Applications\BlueNRG-Tile_Demo\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STEVAL-BCN002V1.bin
  postbuild: "BlueNRG2_EWARM.cmd" "$PROJ_DIR$" STEVAL-BCN002V1 STEVAL-BCN002V1.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __nvmbase_data
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Library\libBlueNRG_Mesh_CM0.a; ..\..\..\..\..\..\Middlewares\ST\ST_Cryptolib\BNRG1\Lib\libcrypto_V300_CM0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/OTA
    ../../../../../../Middlewares/ST/BlueNRG1/BLE_Application/OTA/src/: OTA_btl.c
  group Application/User
    ../../Src/: appli_generic.c appli_light.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_vendor.c BlueNRG1_it.c hal.c main.c models_if.c pal_nvm.c
  group Drivers/BlueNRG1_Periph_Driver
    ../../../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Drivers/BSP/Components/VL53L1X_UltraLite
    ../../../../../../Drivers/BSP/Components/VL53L1X_UltraLite/src/: VL53L1X_api.c VL53L1X_calibration.c VL53L1X_platform.c
  group Drivers/BSP/SDK_Eval_BlueNRG1
    ../../../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: HTS221.c HTS221_Driver.c HTS221_HAL.c LIS2MDL.c LPS22HH.c LPS25HB.c LSM6DS3.c LSM6DSO.c PWM_config.c PWM_handlers.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Middlewares/BlueNRG1/Bluetooth_LE
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/BlueNRG1/HAL
    ../../../../../../Middlewares/ST/BlueNRG1/hal/src/: clock.c context_switch.s fifo.c gp_timer.c hal_radio.c miscutil.c osal.c radio_ota.c sleep.c
  group Middlewares/ST_BLE_Mesh
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Src/: mesh_cfg.c
  group Middlewares/ST_BLE_Mesh/MeshModel
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c time_scene.c vendor.c
