# IAR project Project.ewp, settings and files
configuration Smart_Plug (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ENABLE_USART; BLUENRG1_DEVICE; SERIAL_ENABLE; DISABLE_TRACES; SMART_PLUG; SERVER
  ICCARM.CCDiagSuppress: Pa050, Pe161
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Drivers\BSP\PWM\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\OTA\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\Utils\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc; ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc; ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc; ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\layers_inc; ..\..\..\..\..\..\Drivers\BSP\STEVAL-BLUEPLUG1\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\handlers\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\include\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\nvm\handlers\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\nvm\mnsh\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\nvm\tasks\inc; ..\..\..\..\..\..\Middlewares\ST\Metrology\tasks\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BlueNRG1_Smart_Plug_Demo.bin
  postbuild: "Bluenrg1_EWARM.cmd" "$PROJ_DIR$" Smart_Plug BlueNRG1_Smart_Plug_Demo.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __nvmbase_data
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Library\libBlueNRG_Mesh_CM0_RF_PLUG.a; ..\..\..\..\..\..\Middlewares\ST\ST_Cryptolib\BNRG1\Lib\libcrypto_V300_CM0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: appli_generic.c appli_light.c appli_mesh.c appli_nvm.c appli_sensor.c appli_vendor.c BlueNRG1_it.c hal.c main.c meter.c metering.c models_if.c pal_nvm.c
  group Drivers/BlueNRG1_Periph_Driver
    ../../../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Drivers/BSP/STEVAL-BLUEPLUG1
    ../../../../../../Drivers/BSP/STEVAL-BLUEPLUG1/src/: BLUEPLUG1_Button.c BLUEPLUG1_Com.c BLUEPLUG1_Config.c BLUEPLUG1_Led.c metrology.c metrology_hal.c Metrology_Init.c PWM_config.c PWM_handlers.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Middlewares/BlueNRG1/Bluetooth_LE
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/BlueNRG1/HAL
    ../../../../../../Middlewares/ST/BlueNRG1/hal/src/: clock.c context_switch.s fifo.c gp_timer.c hal_radio.c miscutil.c osal.c radio_ota.c sleep.c
  group Middlewares/Metrology/Handlers
    ../../../../../../Middlewares/ST/Metrology/handlers/src/: handler_metrology.c
  group Middlewares/Metrology/Include
    ../../../../../../Middlewares/ST/Metrology/include/inc/: st_device.h
  group Middlewares/Metrology/Task
    ../../../../../../Middlewares/ST/Metrology/tasks/src/: metroTask.c
  group Middlewares/ST_BLE_Mesh
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Src/: mesh_cfg.c
  group Middlewares/ST_BLE_Mesh/MeshModel
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c time_scene.c vendor.c
