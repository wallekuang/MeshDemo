# Keil uVision project Project.uvprojx, settings and files
target Blue_Tile (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blue_Tile_Demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ, LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ, SMPS_INDUCTOR=SMPS_INDUCTOR_10uH,no_ENABLE_USART,BLUENRG2_DEVICE,USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM,DISABLE_TRACES,LPS22HH_ENABLED,LSM6DSO_ENABLED,HTS221_ENABLED,BLUETILE_SMART_SENSOR,BLUENRG_TILE,BLUETILE_SMART_SWITCH, SERVER
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Drivers\BSP\Components\VL53L1X_UltraLite\inc;..\..\..\..\..\..\Drivers\BSP\PWM\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\OTA\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\BLE_Application\Utils\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc;..\..\..\..\..\..\Projects\BlueNRG-2\Applications\BlueNRG-Tile_Demo\Inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  group Application/User
    ../../Src/: BlueNRG1_it.c hal.c main.c appli_mesh.c appli_generic.c models_if.c appli_vendor.c appli_light.c appli_sensor.c appli_nvm.c pal_nvm.c data.s appli_light_lc.c
  group Drivers/BSP/SDK_Eval_BlueNRG1
    ../../../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c PWM_config.c PWM_handlers.c HTS221.c HTS221_HAL.c LIS2MDL.c LPS22HH.c LSM6DSO.c
  group Drivers/BlueNRG1_Periph_Driver
    ../../../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Middlewares/BlueNRG1/Bluetooth_LE
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/src/: stack_user_cfg.c
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/library/: libbluenrg1_stack.a
  group Middlewares/BlueNRG1/HAL
    ../../../../../../Middlewares/ST/BlueNRG1/hal/src/: clock.c gp_timer.c osal.c sleep.c context_switch.s fifo.c miscutil.c radio_ota.c
  group Middlewares/Cryptographic_Library
    ../../../../../../Middlewares/ST/ST_Cryptolib/BNRG1/Lib/: libcrypto_V300_CM0.a
  group Middlewares/ST/ST_BLE_Mesh/MeshModel
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: generic.c vendor.c light.c common.c sensors.c time_scene.c
  group Middlewares/ST/ST_BLE_Mesh
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Src/: mesh_cfg.c serial_if.c
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Library/: libBlueNRG_Mesh_CM0.a
  group Output
    ./Listings/: BlueNRG2_Lighting_Demo.map
  group Drivers/BSP/Components/VL53L1X_UltraLite
    ../../../../../../Drivers/BSP/Components/VL53L1X_UltraLite/src/: VL53L1X_api.c VL53L1X_calibration.c VL53L1X_platform.c
